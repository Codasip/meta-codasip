require qemu-hobgoblin.inc
