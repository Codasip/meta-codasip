FILESEXTRAPATHS:prepend :=  "${FILE_DIRNAME}:"

SRC_URI += " \
    file://0001-posixtm-pacify-clang-18.patch \
"
